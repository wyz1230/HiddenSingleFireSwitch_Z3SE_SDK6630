# IAR project HiddenSingleFireSwitch_Z3SE_SDK6630.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F768IM32 SiliconLaboratories EFR32MG21A010F768IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F768IM32; ATTRIBUTE_STORAGE_CONFIGURATION="HiddenSingleFireSwitch_Z3SE_SDK6630_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="HiddenSingleFireSwitch_Z3SE_SDK6630_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="HiddenSingleFireSwitch_Z3SE_SDK6630.h"; __SOURCEFILE__="$FILE_FNAME$"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; NO_LED=1; REPORTING_CALLBACK_CODE; EMBER_PAN_ID_CONFLICT_REPORT_THRESHOLD=63; SCENES_RECALL_SAVED_SECENE_CALLBACK_CODE; SCENES_ENHANCE_CMD_CALLBACK_CODE; USED_CUSTOM_BUTTON_DRIVER_CODE; USE_CUSTOM_RJOIN_CODE; USER_OTA_CLIENT_CALLBACK_CODE; USE_ATRRIBUTE_RESET_DEFAULT_CALLBACK_CODE; USE_CUSTOM_NETWORK_STEERING_CODE; USE_ZCL_CLUSTER_SPECIFIC_COMMAND_PARSE_CALLBACK; USED_CUSTOM_HFX_CTUNE_CODE; USE_CUSTOM_INSTALLCODE_CODE; ORB_PRODUCTION_TEST_CODE; USE_CUSTOM_PRE_IDLE_SLEEP_PROC_CODE; PREVENT_LONG_TIME_AWAKE_CODE; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="configs/config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=6; NVM3_DEFAULT_CACHE_SIZE=500; NVM3_MAX_OBJECT_SIZE=500; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..; ..\..\protocol\zigbee\app\framework; ..\..\protocol\zigbee\app\framework\..\..; ..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\protocol\zigbee\app\framework\..\util; ..\..\protocol\zigbee\app\framework\include; ..\..\platform\base\hal; ..\..\platform\base\hal\plugin; ..\..\platform\base\hal\..; ..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\platform\base\hal\..\..\emdrv\config; ..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\platform\base\hal\..\..\emlib\inc; ..\..\platform\base\hal\..\..\middleware\glib; ..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\platform\halconfig\inc\hal-config; ..\..\hardware\module\config; ..\..\hardware\kit\common\halconfig; ..\..\hardware\kit\common\bsp; hal-config; switch_app; switch_app\custom_network_steering; ..\..\platform\bootloader; ..\..\platform\emdrv\nvm3\inc; ..\..\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\platform\radio\rail_lib\common; ..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\platform\radio\rail_lib\protocol\ble; ..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\platform\radio\rail_lib\protocol\zwave; ..\..\util\plugin\plugin-common\mbedtls; ..\..\util\third_party\mbedtls; ..\..\util\third_party\mbedtls\include; ..\..\util\third_party\mbedtls\include\mbedtls; ..\..\util\third_party\mbedtls\sl_crypto\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F768IM32; ATTRIBUTE_STORAGE_CONFIGURATION="HiddenSingleFireSwitch_Z3SE_SDK6630_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="HiddenSingleFireSwitch_Z3SE_SDK6630_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="HiddenSingleFireSwitch_Z3SE_SDK6630.h"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; NO_LED=1; REPORTING_CALLBACK_CODE; EMBER_PAN_ID_CONFLICT_REPORT_THRESHOLD=63; SCENES_RECALL_SAVED_SECENE_CALLBACK_CODE; SCENES_ENHANCE_CMD_CALLBACK_CODE; USED_CUSTOM_BUTTON_DRIVER_CODE; USE_CUSTOM_RJOIN_CODE; USER_OTA_CLIENT_CALLBACK_CODE; USE_ATRRIBUTE_RESET_DEFAULT_CALLBACK_CODE; USE_CUSTOM_NETWORK_STEERING_CODE; USE_ZCL_CLUSTER_SPECIFIC_COMMAND_PARSE_CALLBACK; USED_CUSTOM_HFX_CTUNE_CODE; USE_CUSTOM_INSTALLCODE_CODE; ORB_PRODUCTION_TEST_CODE; USE_CUSTOM_PRE_IDLE_SLEEP_PROC_CODE; PREVENT_LONG_TIME_AWAKE_CODE; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="configs/config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=6; NVM3_DEFAULT_CACHE_SIZE=500; NVM3_MAX_OBJECT_SIZE=500; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..; ..\..\protocol\zigbee\app\framework; ..\..\protocol\zigbee\app\framework\..\..; ..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\protocol\zigbee\app\framework\..\util; ..\..\protocol\zigbee\app\framework\include; ..\..\platform\base\hal; ..\..\platform\base\hal\plugin; ..\..\platform\base\hal\..; ..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\platform\base\hal\..\..\emdrv\config; ..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\platform\base\hal\..\..\emlib\inc; ..\..\platform\base\hal\..\..\middleware\glib; ..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\platform\halconfig\inc\hal-config; ..\..\hardware\kit\common\halconfig; ..\..\hardware\kit\common\bsp; hal-config; switch_app; switch_app\custom_network_steering; ..\..\platform\bootloader; ..\..\platform\emdrv\nvm3\inc; ..\..\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\platform\radio\rail_lib\common; ..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\platform\radio\rail_lib\protocol\ble; ..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\platform\radio\rail_lib\protocol\zwave; ..\..\util\plugin\plugin-common\mbedtls; ..\..\util\third_party\mbedtls; ..\..\util\third_party\mbedtls\include; ..\..\util\third_party\mbedtls\include\mbedtls; ..\..\util\third_party\mbedtls\sl_crypto\include
  OBJCOPY.OOCOutputFile: HiddenSingleFireSwitch_Z3SE_SDK6630.s37
  prebuild: HiddenSingleFireSwitch_Z3SE_SDK6630-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: HiddenSingleFireSwitch_Z3SE_SDK6630-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: HiddenSingleFireSwitch_Z3SE_SDK6630.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=786432; RAM_SIZE=65536; FLASH_PAGE_SIZE=8192; SIMEEPROM_SIZE=49152; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HEADER_SIZE=512; LOCAL_STORAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: ..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../protocol/zigbee/app/framework/plugin/aes-cmac/: aes-cmac.c
    ../../util/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../util/third_party/mbedtls/sl_crypto/src/: aes_aes.c crypto_aes.c crypto_ble.c crypto_ecp.c crypto_management.c crypto_sha.c cryptoacc_aes.c cryptoacc_ccm.c cryptoacc_cmac.c cryptoacc_ecp.c cryptoacc_gcm.c cryptoacc_management.c cryptoacc_sha.c cryptoacc_trng.c entropy_adc.c entropy_rail.c radioaes.c radioaes_aes.c radioaes_ble.c se_aes.c se_ccm.c se_cmac.c se_ecp.c se_jpake.c se_management.c se_sha.c se_trng.c shax.c trng.c
    ../../protocol/zigbee/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../protocol/zigbee/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    switch_app/: app-callback.c scenes-recall-transition-proc.c
    ../../platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c bootloader-interface-app.c bootloader-interface.c button.c cstartup-common.c diagnostic.c ext-device.c faults-v7m.s79 hal-config-gpio.c hal-config.c isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c
    ../../protocol/zigbee/app/framework/plugin/basic/: basic.c
    ../../platform/bootloader/api/: btl_interface.c btl_interface_storage.c
    switch_app/buttons_app/: buttons-app.c
    switch_app/buttons_driver/: buttons-driver.c
    ../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ./: call-command-handler.c callback-stub.c HiddenSingleFireSwitch_Z3SE_SDK6630_callbacks.c stack-handler-stub.c znet-bookkeeping.c znet-cli.c
    ../../protocol/zigbee/stack/framework/: ccm-star.c strong-random-api.c
    ../../platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c coulomb-counter-802154.c
    ../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../protocol/zigbee/app/util/serial/: command-interpreter2.c
    ../../protocol/zigbee/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../protocol/zigbee/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    switch_app/custom_network_steering/: custom-network-steering.c
    ../../platform/base/hal/plugin/debug-jtag-stub/: debug-jtag-stub.c
    switch_app/device_app_infomation/: device-app-infomation.c
    ../../util/plugin/plugin-afv2/eeprom/: eeprom-afv2.c
    ../../util/plugin/plugin-common/eeprom/: eeprom-cli.c eeprom.c
    ../../platform/emlib/src/: em_iadc.c
    ../../platform/base/hal/: ember-base-configuration.c
    ../../protocol/zigbee/stack/config/: ember-configuration.c
    ../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../protocol/zigbee/app/framework/plugin/end-device-support/: end-device-move.c end-device-support-cli.c end-device-support.c polling-common.c polling-soc.c
    ../../protocol/zigbee/app/framework/plugin/find-and-bind-target/: find-and-bind-target-cli.c find-and-bind-target.c
    ../../protocol/zigbee/app/framework/plugin/groups-server/: groups-server-cli.c groups-server.c
    ../../protocol/zigbee/app/framework/plugin/identify/: identify-cli.c identify.c
    switch_app/identify_coordinator_manufacturer/: identify-coordinator-manufacturer.c
    ../../protocol/zigbee/app/framework/plugin-soc/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    switch_app/leds_app/: leds-app.c
    switch_app/leds_driver/: leds-driver.c
    ../../protocol/zigbee/app/util/common/: library.c
    ../../protocol/zigbee/app/framework/plugin/manufacturing-library-cli/: manufacturing-library-cli-soc.c
    switch_app/network_status_process/: network-status-process.c
    ../../protocol/zigbee/app/framework/plugin/network-steering/: network-steering-cli.c network-steering-soc.c network-steering-v2.c network-steering.c
    ../../platform/emdrv/nvm3/src/: nvm3_default.c nvm3_hal_flash.c nvm3_lock.c
    ../../protocol/zigbee/app/framework/plugin/on-off/: on-off.c
    ../../protocol/zigbee/app/framework/plugin/ota-bootload/: ota-bootload-cli.c ota-bootload-soc.c
    ../../protocol/zigbee/app/framework/plugin/ota-client/: ota-client-cli.c ota-client-page-request.c ota-client-signature-verify.c ota-client.c
    ../../protocol/zigbee/app/framework/plugin/ota-client-policy/: ota-client-policy.c
    ../../protocol/zigbee/app/framework/plugin/ota-common/: ota-common.c
    ../../protocol/zigbee/app/framework/plugin/ota-storage-common/: ota-storage-common-cli.c ota-storage-common.c
    ../../protocol/zigbee/app/framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c ota-storage-eeprom.c
    ../../protocol/zigbee/app/framework/plugin/ota-storage-simple/: ota-storage-simple.c
    switch_app/production_test/: production-test.c
    switch_app/rejoin_interval_proc/: rejoin-interval-proc.c
    switch_app/relay_control_buffer/: relay-control-buffer.c
    switch_app/relay_control_driver/: relay-control-driver.c
    ../../protocol/zigbee/app/framework/plugin/reporting/: reporting-cli.c reporting-default-configuration.c reporting.c
    ../../protocol/zigbee/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../protocol/zigbee/app/framework/plugin/scenes/: scenes-cli.c scenes.c
    ../../protocol/zigbee/app/util/security/: security-address-cache.c
    ../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../protocol/zigbee/app/framework/plugin/simple-main/: simple-main.c
    switch_app/software_reboot_proc/: software-reboot-proc.c
    switch_app/specific_zcl_cluster_cmd_parse/: specific-zcl-cluster-cmd-parse.c
    switch_app/switch_identify/: switch-identify.c
    switch_app/switch_ways_config/: switch-ways-config.c
    switch_app/production_test/tiny_cli/: tiny_cli.c
    switch_app/production_test/tiny_printf/: tiny_printf.c
    ../../platform/emdrv/uartdrv/src/: uartdrv.c
    ../../protocol/zigbee/app/framework/plugin/update-tc-link-key/: update-tc-link-key-cli.c update-tc-link-key.c
    switch_app/production_test/md5_encryption/: WjCryptLib_MD5.c
    ../../protocol/zigbee/app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../platform/emdrv/dmadrv/src/: dmadrv.c
    ../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../platform/emdrv/sleep/src/: sleep.c
    ../../platform/emdrv/tempdrv/src/: tempdrv.c
    ../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../platform/emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group Libraries
    ../../protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg21-rail/: binding-table-library.a
    ../../protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-163k1-stub-library.a
    ../../protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-283k1-stub-library.a
    ../../protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-sign-stub.a
    ../../protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-stub.a
    ../../protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-stub-library.a
    ../../protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg21-rail/: debug-basic-library.a
    ../../protocol/zigbee/build/debug-extended-stub-library-cortexm3-iar-efr32mg21-rail/: debug-extended-stub-library.a
    ../../protocol/zigbee/build/end-device-bind-stub-library-cortexm3-iar-efr32mg21-rail/: end-device-bind-stub-library.a
    ../../protocol/zigbee/build/gp-stub-library-cortexm3-iar-efr32mg21-rail/: gp-stub-library.a
    ../../protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg21-rail/: hal-library.a
    ../../protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg21-rail/: install-code-library.a
    ../../platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
    ../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg21_iar_release.a
    ../../protocol/zigbee/build/mfglib-library-cortexm3-iar-efr32mg21-rail/: mfglib-library.a
    ../../protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg21-rail/: multi-network-stub-library.a
    ../../protocol/zigbee/build/packet-validate-library-cortexm3-iar-efr32mg21-rail/: packet-validate-library.a
    ../../protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg21-rail/: security-library-core.a
    ../../protocol/zigbee/build/security-library-link-keys-stub-cortexm3-iar-efr32mg21-rail/: security-library-link-keys-stub.a
    ../../protocol/zigbee/build/sim-eeprom2-to-nvm3-upgrade-stub-library-cortexm3-iar-efr32mg21-rail/: sim-eeprom2-to-nvm3-upgrade-stub-library.a
    ../../protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg21-rail/: zigbee-pro-stack.a
    ../../protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg21-rail/: zigbee-r22-support-stub-library.a
    ../../protocol/zigbee/build/zll-stub-library-cortexm3-iar-efr32mg21-rail/: zll-stub-library.a
